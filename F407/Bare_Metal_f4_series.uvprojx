# Keil uVision project Bare_Metal_f4_series.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bare_Metal_f4_series
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Headers
    ./: All_headers.h clocks_f407.h LEDs_f4.h timers_f407.h uart_f407.h SPI_F407.h I2C_f407.h adc_f407.h gpio_header_f4.h PWM_f4.h dac_f407.h serial_color_codes.h IWDG_WWDG_F407.h
  group Drivers
    ./: Clock_drivers_f407.c LED_Drivers_f4.c timer_drivers_f407.c uart_drivers_f407.c SPI_drivers_f407.c I2C_Drivers_f407.c ADC_Drivers_F407.c GPIO_f4_drivers.c PWM_f4_drivers.c DAC_Drivers_f407.c IWDG_WWDG_F407_Drivers.c
  group main
    ./: Clocks_f407.c LED_f407_blink.c timers_f407.c Uart_f407.c Uart_it_f407.c SPI_f407.c I2C_f407.c Uart_f407_dma.c ADC_F407.c gpio_main_f4.c pwm_main.c DAC_f407_main.c IWDG_WWDG_main.c
  group rough
    ./: rough_wrk.txt
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
