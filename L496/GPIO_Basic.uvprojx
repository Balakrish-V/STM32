# Keil uVision project GPIO_Basic.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32L496ZGTxP STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: GPIO_Basic
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Headers
    ./: clocks.h timers.h LEDs.h gpio_header.h IWDG_WWDG.h UART_header.h adc_header.h dac_header.h spi_header.h serial_color_codes.h pwm.h i2c_header.h lib_headers.h
  group Drivers
    ./: clock_drivers.c timers.c LED_drivers.c gpio_drivers.c IWDG_WWDG.c UART_driver.c adc_driver.c dac_driver.c spi_driver.c pwm_drivers.c i2c_drivers.c dac_with_timer.c
  group Source Group 1
    ./: LED_main.c main_timer.c main_gpio.c SPI_main.c main_wdg.c main_dac.c main_adc.c main_uart.c adc_main_new.c main_pwm.c main_i2c.c spi_f407_bare_metal.c SPI_Bare_Metal.c
  group Rough
    ./: rough_sketch.txt
software components: CMSIS:CORE 6.1.0, Device:Startup 1.3.2
